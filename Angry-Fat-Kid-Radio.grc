<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Dell Sackett</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Angry Fat Kid Radio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>8192</value></param>
<param><key>gui_hint</key><value>5,0,1,8</value></param>
<param><key>label0</key><value>"2048"</value></param>
<param><key>label1</key><value>"4096"</value></param>
<param><key>label2</key><value>"8192"</value></param>
<param><key>label3</key><value>"16384"</value></param>
<param><key>label4</key><value>"32768"</value></param>
<param><key>label</key><value>FFT</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>2048</value></param>
<param><key>option1</key><value>4096</value></param>
<param><key>option2</key><value>8192</value></param>
<param><key>option3</key><value>16384</value></param>
<param><key>option4</key><value>32768</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>100e6</value></param>
<param><key>gui_hint</key><value>0,0,5,100</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>30e6</value></param>
<param><key>step</key><value>100000</value></param>
<param><key>stop</key><value>6e9</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10000000</value></param>
<param><key>gui_hint</key><value>5,8,1,8</value></param>
<param><key>label0</key><value>"512K"</value></param>
<param><key>label1</key><value>"1M"</value></param>
<param><key>label2</key><value>"5M"</value></param>
<param><key>label3</key><value>"10M"</value></param>
<param><key>label4</key><value>"20M"</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>512000</value></param>
<param><key>option1</key><value>1000000</value></param>
<param><key>option2</key><value>5000000</value></param>
<param><key>option3</key><value>10000000</value></param>
<param><key>option4</key><value>20000000</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value>hackrf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>fft_size</value></param>
<param><key>gui_hint</key><value>tab@0:0,0,100,100</value></param>
<param><key>name</key><value>Summary</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>gui_hint</key><value>6,0,94,100</value></param>
<param><key>label0</key><value>Summary</value></param>
<param><key>label1</key><value>RF</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
